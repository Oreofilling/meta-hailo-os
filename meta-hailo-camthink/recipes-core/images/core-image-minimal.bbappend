# Product OS baseline plus the slot-independent application bootstrap contract.
IMAGE_INSTALL:append = " \
    packagegroup-camthink-system \
    aipc-bootstrap \
"
