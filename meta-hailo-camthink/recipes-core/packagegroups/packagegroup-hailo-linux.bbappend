# systemd-timesyncd is the single image time synchronization provider.
RDEPENDS:${PN}-networking-dev-pkg:remove:hailo15-ne503 = "ntp"
